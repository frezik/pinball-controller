# Repository frezik/pinball-controller

## KiCad design mainboard/pinball.kicad_pcb

Parts:
C1, C2: 10uF; C_0603; Digikey # 490-3298-1-ND
C3, C4: 22pF; C_0603; Digikey # 478-1167-1-ND
CON1: AVR-ISP-6; Pin_Header_Straight_2x03
D1, D2, D3, D4: D_Schottky; SOD-323; Digikey # 497-3707-1-ND
D5: LED; LED-0603; Digikey # 160-1447-1-ND
IC1: ATMEGA328-A; TQFP-32_7x7mm_Pitch0.8mm; Digikey # ATMEGA328-AURCT-ND
J1: Conn_01x14; Pin_Header_Straight_2x07
J2: Conn_01x02; Pin_Header_Straight_1x02
J3: Conn_01x03_Male; Pin_Header_Straight_1x03
P1, P2, P3, P4: SCREW_PLACEHOLDER; MountingHole_3.2mm_M3_DIN965_Pad
P5: PWR; TerminalBlock_Pheonix_MKDS1.5-4pol
P7: CONN_02X24; Pin_Header_Straight_2x24
Q1, Q3, Q5, Q7: Q_NMOS_GDS; TO-220_Neutral123_Vertical; Digikey # 497-2757-5-ND
R57: 150; R_0603; Digikey # RNCP0603FTD150RCT-ND
U1: R-78B5.0-2.0; TO-220; Digikey # 945-3042-ND
U2: Teensy3.2; Teensy35_36_edge
U3: 74AHC125; TSSOP-14_4.4x5mm_Pitch0.65mm; Digikey # 1727-6305-1-ND
W1, W2, W3: TEST_1P; Measurement_Point_Round-SMD-Pad_Big
Y1: Crystal; Crystal_HC49-SD_SMD; Digikey # 535-10226-1-ND

Connections:
+5V: C2.1, CON1.2, D5.2 (A), IC1.4 (VCC), IC1.6 (VCC), IC1.18 (AVCC), IC1.20 (AREF), J3.2, P5.4, U2.53 (Vin), U2.55 (AREF), U3.14 (VCC), W3.1
FLIPPER_ON_RELAY: J1.9, U2.37 (A21_DAC0)
GND: C1.2, C2.2, C3.1, C4.1, CON1.6, IC1.3 (GND), IC1.5 (GND), IC1.21 (GND), J1.14, J3.3, P1.1, P2.1, P3.1, P4.1, P5.2, P5.3, P7.2, P7.4, P7.6, P7.8, P7.10, P7.12, P7.14, P7.16, P7.18, P7.20, P7.22, P7.24, P7.26, P7.28, P7.30, P7.32, P7.34, P7.36, P7.38, P7.40, P7.42, P7.44, P7.46, P7.48, Q1.3 (S), Q3.3 (S), Q5.3 (S), Q7.3 (S), R57.2, U2.1 (GND), U2.52 (AGND), U3.1 (1~DE), U3.7 (GND), W2.1; also elsewhere on the board
MISO_AVR: CON1.1, IC1.16 ((PCINT4/MISO)PB4)
MOSI_AVR: CON1.4, IC1.15 ((PCINT3/OC2A/MOSI)PB3)
NEOPIXEL: U2.30 (33_A14_CAN1TX_scl0), U3.2 (1A)
unnamed: D5.1 (K), R57.1
unnamed: J3.1, U3.3 (1Y)
RST: CON1.5, IC1.29 ((PCINT14/~RESET~)PC6)
RX: J2.1, U2.23 (31_A12_RX4_CS1)
SCK_AVR: CON1.3, IC1.17 ((PCINT5/SCK)PB5)
SCL: IC1.28 ((PCINT13/SCL/ADC5)PC5), U2.46 (19_A5_SCL0_Touch)
SCORE1: IC1.10 ((PCINT22/OC0A/AIN0)PD6), Q7.1 (G)
SCORE2: IC1.12 ((PCINT0/CLKO/ICP1)PB0), Q5.1 (G)
SCORE3: IC1.14 ((PCINT2/OC1B/~SS~)PB2), Q3.1 (G)
SCORE4: IC1.24 ((PCINT9/ADC1)PC1), Q1.1 (G)
SCORE_OUT1A: D4.2 (A), J1.1, Q7.2 (D)
SCORE_OUT2A: D3.2 (A), J1.3, Q5.2 (D)
SCORE_OUT3A: D2.2 (A), J1.5, Q3.2 (D)
SCORE_OUT4A: D1.2 (A), J1.7, Q1.2 (D)
SCORE_ZERO1: IC1.11 ((PCINT23/AIN1)PD7); also elsewhere on the board
SCORE_ZERO2: IC1.13 ((PCINT1/OC1A)PB1); also elsewhere on the board
SCORE_ZERO3: IC1.23 ((PCINT8/ADC0)PC0); also elsewhere on the board
SCORE_ZERO4: IC1.25 ((PCINT10/ADC2)PC2); also elsewhere on the board
SCORE_ZERO_IN1: J1.13; also elsewhere on the board
SCORE_ZERO_IN2: J1.12; also elsewhere on the board
SCORE_ZERO_IN3: J1.11; also elsewhere on the board
SCORE_ZERO_IN4: J1.10; also elsewhere on the board
SDA: IC1.27 ((PCINT12/SDA/ADC4)PC4), U2.45 (18_A4_SDA0_Touch)
SWITCH1: P7.27; also elsewhere on the board
SWITCH2: P7.25; also elsewhere on the board
SWITCH3: P7.23; also elsewhere on the board
SWITCH4: P7.21; also elsewhere on the board
SWITCH5: P7.19; also elsewhere on the board
SWITCH6: P7.17; also elsewhere on the board
SWITCH7: P7.15; also elsewhere on the board
SWITCH8: P7.13; also elsewhere on the board
SWITCH9: P7.29; also elsewhere on the board
SWITCH10: P7.11; also elsewhere on the board
SWITCH11: P7.9; also elsewhere on the board
SWITCH12: P7.7; also elsewhere on the board
SWITCH13: P7.5; also elsewhere on the board
SWITCH14: P7.31; also elsewhere on the board
SWITCH15: P7.3; also elsewhere on the board
SWITCH16: P7.1; also elsewhere on the board
SWITCH17: P7.33; also elsewhere on the board
SWITCH18: P7.35; also elsewhere on the board
SWITCH19: P7.37; also elsewhere on the board
SWITCH20: P7.39; also elsewhere on the board
SWITCH21: P7.41; also elsewhere on the board
SWITCH22: P7.43; also elsewhere on the board
SWITCH23: P7.45; also elsewhere on the board
SWITCH24: P7.47; also elsewhere on the board
SWITCH_LOW1: U2.2 (0_RX1_MOSI1_Touch); also elsewhere on the board
SWITCH_LOW2: U2.3 (1_TX1_MISO1_Touch); also elsewhere on the board
SWITCH_LOW3: U2.4 (2_PWM); also elsewhere on the board
SWITCH_LOW4: U2.6 (4_PWM_CAN0RX_SDA2); also elsewhere on the board
SWITCH_LOW5: U2.7 (5_PWM_tx1_miso1); also elsewhere on the board
SWITCH_LOW6: U2.9 (7_RX3_miso0_scl0); also elsewhere on the board
SWITCH_LOW7: U2.11 (9_PWM_RX2_CS0); also elsewhere on the board
SWITCH_LOW8: U2.12 (10_PWM_TX2_CS0); also elsewhere on the board
SWITCH_LOW9: U2.10 (8_TX3_miso0_sda0); also elsewhere on the board
SWITCH_LOW10: U2.16 (24); also elsewhere on the board
SWITCH_LOW11: U2.17 (25); also elsewhere on the board
SWITCH_LOW12: U2.18 (26_tx1); also elsewhere on the board
SWITCH_LOW13: U2.19 (27_rx1); also elsewhere on the board
SWITCH_LOW14: U2.31 (34_A15_CAN1TX_sda0); also elsewhere on the board
SWITCH_LOW15: U2.21 (29_PWM_can0tx_Touch); also elsewhere on the board
SWITCH_LOW16: U2.22 (30_PWM_can0rx_Touch); also elsewhere on the board
SWITCH_LOW17: U2.32 (35_A16_PWM); also elsewhere on the board
SWITCH_LOW18: U2.33 (36_A17_PWM); also elsewhere on the board
SWITCH_LOW19: U2.34 (37_A18_PWM_SCL1); also elsewhere on the board
SWITCH_LOW20: U2.35 (38_A19_PWM_SDA1); also elsewhere on the board
SWITCH_LOW21: U2.36 (39_A20); also elsewhere on the board
SWITCH_LOW22: U2.41 (14_A0_PWM_sck0); also elsewhere on the board
SWITCH_LOW23: U2.42 (15_A1_CS0_Touch); also elsewhere on the board
SWITCH_LOW24: U2.43 (16_A2_scl0_Touch); also elsewhere on the board
TX: J2.2, U2.24 (32_A13_TX4_SCK1)
Vin: C1.1, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), J1.2, J1.4, J1.6, J1.8, P5.1, W1.1
XTAL1: C4.2, IC1.7 ((PCINT6/XTAL1/TOSC1)PB6), Y1.1
XTAL2: C3.2, IC1.8 ((PCINT7/XTAL2/TOSC2)PB7), Y1.2

Parts:
R1, R3, R5, R7, R9, R11, R13, R15, R17, R19, R21, R23, R25, R27, R29, R31, R33, R35, R37, R39, R41, R43, R45, R47, R49, R51, R53, R55: 1.3k; R_0402; Digikey # P1.3KJCT-ND
R2, R4, R6, R8, R10, R12, R14, R16, R18, R20, R22, R24, R26, R28, R30, R32, R34, R36, R38, R40, R42, R44, R46, R48, R50, R52, R54, R56: 620; R_0402; Digikey # P620JCT-ND

Connections:
GND: R2.2, R4.2, R6.2, R8.2, R10.2, R12.2, R14.2, R16.2, R18.2, R20.2, R22.2, R24.2, R26.2, R28.2, R30.2, R32.2, R34.2, R36.2, R38.2, R40.2, R42.2, R44.2, R46.2, R48.2, R50.2, R52.2, R54.2, R56.2; also elsewhere on the board
SCORE_ZERO1: R49.2, R50.1; also elsewhere on the board
SCORE_ZERO2: R53.2, R54.1; also elsewhere on the board
SCORE_ZERO3: R51.2, R52.1; also elsewhere on the board
SCORE_ZERO4: R55.2, R56.1; also elsewhere on the board
SCORE_ZERO_IN1: R49.1; also elsewhere on the board
SCORE_ZERO_IN2: R53.1; also elsewhere on the board
SCORE_ZERO_IN3: R51.1; also elsewhere on the board
SCORE_ZERO_IN4: R55.1; also elsewhere on the board
SWITCH1: R7.1; also elsewhere on the board
SWITCH2: R13.1; also elsewhere on the board
SWITCH3: R25.1; also elsewhere on the board
SWITCH4: R37.1; also elsewhere on the board
SWITCH5: R1.1; also elsewhere on the board
SWITCH6: R15.1; also elsewhere on the board
SWITCH7: R27.1; also elsewhere on the board
SWITCH8: R39.1; also elsewhere on the board
SWITCH9: R3.1; also elsewhere on the board
SWITCH10: R17.1; also elsewhere on the board
SWITCH11: R29.1; also elsewhere on the board
SWITCH12: R41.1; also elsewhere on the board
SWITCH13: R5.1; also elsewhere on the board
SWITCH14: R19.1; also elsewhere on the board
SWITCH15: R31.1; also elsewhere on the board
SWITCH16: R43.1; also elsewhere on the board
SWITCH17: R45.1; also elsewhere on the board
SWITCH18: R33.1; also elsewhere on the board
SWITCH19: R21.1; also elsewhere on the board
SWITCH20: R9.1; also elsewhere on the board
SWITCH21: R11.1; also elsewhere on the board
SWITCH22: R23.1; also elsewhere on the board
SWITCH23: R35.1; also elsewhere on the board
SWITCH24: R47.1; also elsewhere on the board
SWITCH_LOW1: R7.2, R8.1; also elsewhere on the board
SWITCH_LOW2: R13.2, R14.1; also elsewhere on the board
SWITCH_LOW3: R25.2, R26.1; also elsewhere on the board
SWITCH_LOW4: R37.2, R38.1; also elsewhere on the board
SWITCH_LOW5: R1.2, R2.1; also elsewhere on the board
SWITCH_LOW6: R15.2, R16.1; also elsewhere on the board
SWITCH_LOW7: R27.2, R28.1; also elsewhere on the board
SWITCH_LOW8: R39.2, R40.1; also elsewhere on the board
SWITCH_LOW9: R3.2, R4.1; also elsewhere on the board
SWITCH_LOW10: R17.2, R18.1; also elsewhere on the board
SWITCH_LOW11: R29.2, R30.1; also elsewhere on the board
SWITCH_LOW12: R41.2, R42.1; also elsewhere on the board
SWITCH_LOW13: R5.2, R6.1; also elsewhere on the board
SWITCH_LOW14: R19.2, R20.1; also elsewhere on the board
SWITCH_LOW15: R31.2, R32.1; also elsewhere on the board
SWITCH_LOW16: R43.2, R44.1; also elsewhere on the board
SWITCH_LOW17: R45.2, R46.1; also elsewhere on the board
SWITCH_LOW18: R33.2, R34.1; also elsewhere on the board
SWITCH_LOW19: R21.2, R22.1; also elsewhere on the board
SWITCH_LOW20: R9.2, R10.1; also elsewhere on the board
SWITCH_LOW21: R11.2, R12.1; also elsewhere on the board
SWITCH_LOW22: R23.2, R24.1; also elsewhere on the board
SWITCH_LOW23: R35.2, R36.1; also elsewhere on the board
SWITCH_LOW24: R47.2, R48.1; also elsewhere on the board

Notes on the sheet:
If we need to handle 43-50V, use 50kOhm and 5000kOhm resistors. 1/16W is fine

Board: 2 copper layers, 83.8 x 48.3 mm, 85 parts (28 on the bottom side), 81 nets.

## Commit log

2018-04-11 Move mainboard files
2018-04-11 Fetch libraries
2018-05-08 Start on PCB layout
2018-05-11 Input firmware
2018-05-11 Start on score firmware
2019-02-05 KiCad 5.0 conversion. Start on slimming PCB.
2019-02-06 Voltage dividers on switch pins
2019-02-07 Add power LED
2019-02-07 Neopixel out. Lay out traces.
2019-02-08 Cleanup labels
2019-02-08 Digikey BOM
2019-02-09 Remove 5V regulator. Power directly from MOLEX connector instead. Add CC-BY-SA license.

Notices in the files:
mainboard/pinball.kicad_pcb:
Copyright (c) 2019  Timm Murray
CC-BY-SA 4.0
